# Keil uVision project SpringS_RTOS.uvproj, settings and files
target SpringS_RTOS (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: SpringS_RTOS
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./src/: os.c pll.c springs_rtos_main.c osasm.s startup.s timer.c st7735.c uart.c
  group inc
    ./inc/: os.h pll.h fifo.h st7735.h uart.h timer.h
